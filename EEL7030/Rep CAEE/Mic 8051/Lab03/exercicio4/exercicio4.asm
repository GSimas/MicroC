;MATHEUS FIGUEIREDO
CS 		  EQU P0.7
END0 	  EQU P3.3;
END1 	  EQU P3.4;
ATRASO 	  EQU 05H
		  ORG 0h
		  CLR END0
		  CLR END1
		  SETB CS	
		MOV A,#10H		
		MOV R7,#9
VOLTA:	MOV P1,R7
		CALL DELAY		
		DEC R7
		MOV A,R7
		JZ CONT
		JMP VOLTA
CONT:	MOV P1,#0
		CALL DELAY
		JMP FIM


DELAY:	PUSH Acc
		MOV A,#ATRASO
DELAY2:	DJNZ Acc,DELAY2
		POP Acc
	 	RET	  
FIM:	
		END
